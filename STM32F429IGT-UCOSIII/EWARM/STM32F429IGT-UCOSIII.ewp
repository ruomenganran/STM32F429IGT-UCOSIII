# IAR project STM32F429IGT-UCOSIII.ewp, settings and files
configuration STM32F429IGT-UCOSII (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\BSP; ..\uCOS-III; ..\uCOS-III\uC-BSP; ..\uCOS-III\uC-CONFIG; ..\uCOS-III\uC-CPU; ..\uCOS-III\uC-CPU\ARM-Cortex-M4\IAR; ..\uCOS-III\uC-LIB; ..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\IAR; ..\uCOS-III\uCOS-III; ..\uCOS-III\uCOS-III\Source; ..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F429IGT-UCOSII.hex
  ILINK.IlinkOutputFile: STM32F429IGT-UCOSII.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group BSP
    ../BSP/: printf_support.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group UCOS-III/UCOSIII-Bsp
    ../uCOS-III/uC-BSP/: bsp.c
  group UCOS-III/UCOSIII-Config
    ../uCOS-III/uC-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOS-III/UCOSIII-Core
    ../uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
  group UCOS-III/UCOSIII-Cpu
    ../uCOS-III/uC-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm cpu_c.c
    ../uCOS-III/uC-CPU/: cpu_core.c
  group UCOS-III/UCOSIII-Lib
    ../uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
